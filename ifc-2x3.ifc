Properties of the parts of a building model (IFC2X3)

# File
Description: Lufterhitzer-Thermostat, 70…100 °C (Brenner), 20…70 °C (Ventilator), Kapillarlänge 350 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6110013, Lufterhitzer-Thermostat, 70…100 °C (Brenner), 20…70 °C (Ventilator), Kapillarlänge 350 mm
In: Raum
Description: Minimal- oder Maximalthermostat zur Zuluftüberwachung und Ventilatorregelung in Lüftungs- und Klimaanlagen. Bauartgeprüft durch TÜV nach DIN EN 14597. Für Warmlufterhitzer nach DIN 4794. Fühlerbruch: Bei Fühlerbeschädigung oder Fühlerbruch öffnen die Kontakte 1 und 4 des Ventilators. Eigensicherheit/Kälteschutz: Die Geräte sind eigensicher, d. h. bei Verlust des Fühlermediums z. B. durch Fühlerbruch, wird der Brenner abgeschaltet. Da Minustemperaturen durch Volumenverringerung des Fühlermediums denselben Effekt erzeugen, werden die Geräte mittels der „Kälteschraube“ so justiert, dass sie erst bei Temperaturen unter –15 °C den Brenner abschalten. Die Wiedereinschaltung kann nur manuell bei höheren Temperaturen als ca. –5 °C mittels der Handrückstelltaste erfolgen. Überhitzungsschutz: Das Gerät schützt vor unkontrollierter Überhitzung, verursacht z. B. durch Wärmestau oder durch schleichenden Kapillarfüllverlust bei nicht sichtbaren Beschädigungen des Fühlers oder des Kapillarrohres etc. Bei Erreichen einer Temperatur von 220 °C schmilzt das Sicherheitslot im Fühler und das Gerät schaltet, durch Verlust des Füllmediums, den Brenner zur sicheren Seite hin ab. Der Brenner ist nicht wiedereinschaltbar. Das Gerät ist dann unbrauchbar und dient als Nachweis der vorhanden gewesenen Übertemperatur von mindestens 220 °C.; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6110013; ModelLabel: JTL-2; GlobalTradeItemNumber: 4050528030788; ProductURL: https://alre.de/produkt_E6110013
Pset_Specification - NominalLength: 0.139 m; NominalWidth: 0.083 m; NominalDepth: 0.058 m; NetWeight: 0.824
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 80; Ausführung des Sensors: Kapillarrohr; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP20; Elektronische Ausführung: no; Geeignet als Wächter: yes; Mediumtemperatur: -15; Schaltdifferenz der Temperatur: 8; Anzahl der Kontakte als Wechsler: 2; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6110013.pdf
